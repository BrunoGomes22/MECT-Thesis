options:
  parameters:
    generate_options: no_gui
    id: multi_ue_scenario_headless_12
    output_language: python
    title: srsRAN_multi_UE_12
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '11520000'
  states: {}
- name: slow_down_ratio
  id: variable_qtgui_range
  parameters:
    label: Time Slow Down Ratio
    start: '1'
    step: '1'
    stop: '32'
    value: '4'
  states: {state: disabled}
- name: slow_down_ratio
  id: variable
  parameters:
    value: '1'
  states: {}
- name: ue10_path_loss_db
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ue11_path_loss_db
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ue12_path_loss_db
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ue1_path_loss_db
  id: variable_qtgui_range
  parameters:
    label: UE1 Pathloss [dB]
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {state: disabled}
- name: ue1_path_loss_db
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ue2_path_loss_db
  id: variable_qtgui_range
  parameters:
    label: UE2 Pathloss [dB]
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {state: disabled}
- name: ue2_path_loss_db
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ue3_path_loss_db
  id: variable_qtgui_range
  parameters:
    label: UE3 Pathloss [dB]
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {state: disabled}
- name: ue3_path_loss_db
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ue4_path_loss_db
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ue5_path_loss_db
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ue6_path_loss_db
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ue7_path_loss_db
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ue8_path_loss_db
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ue9_path_loss_db
  id: variable
  parameters:
    value: '0'
  states: {}
- name: zmq_hwm
  id: variable
  parameters:
    value: '-1'
  states: {}
- name: zmq_timeout
  id: variable
  parameters:
    value: '100'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '12'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue1_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue2_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue3_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue4_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue5_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue6_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue6_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue7_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue8_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue9_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue10_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_0_0_0_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue11_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_0_0_0_0_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue12_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue7_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue8_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_0_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue9_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_0_1_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue10_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_0_1_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue11_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_0_1_0_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue12_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue5_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue4_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue1_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue3_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue2_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 1.0*samp_rate/(1.0*slow_down_ratio)
    type: complex
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2100
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_rep_sink_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2200
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_rep_sink_0_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2001
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_rep_sink_0_2
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2300
    hwm: zmq_hwm
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_0_2_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2400
    hwm: zmq_hwm
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_0_2_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2500
    hwm: zmq_hwm
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_0_2_2
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2600
    hwm: zmq_hwm
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_0_2_2_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2700
    hwm: zmq_hwm
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_0_2_2_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2800
    hwm: zmq_hwm
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_0_2_2_0_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2900
    hwm: zmq_hwm
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_0_2_2_0_0_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:3000
    hwm: zmq_hwm
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_0_2_2_0_0_0_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:3100
    hwm: zmq_hwm
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_0_2_2_0_0_0_2
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:3200
    hwm: zmq_hwm
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2000
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2301
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_0_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2401
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_0_0_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2501
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_0_0_0_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2601
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_0_0_0_0_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2701
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_0_0_0_0_0_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2801
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_0_0_0_0_0_0_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2901
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_0_0_0_0_0_0_0_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:3001
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_0_0_0_0_0_0_0_0_1
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:3101
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_0_0_0_0_0_0_0_0_2
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:3201
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_1
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2101
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_1_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2201
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}

connections:
- [blocks_add_xx_0, '0', zeromq_rep_sink_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_0_0_0, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_0_0_0_0_0, '0', blocks_add_xx_0, '4']
- [blocks_multiply_const_vxx_0_0_0_0_0_0, '0', blocks_add_xx_0, '5']
- [blocks_multiply_const_vxx_0_0_0_0_0_0_0, '0', zeromq_rep_sink_0_2_2, '0']
- [blocks_multiply_const_vxx_0_0_0_0_0_0_0_0, '0', zeromq_rep_sink_0_2_2_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0_0_0_0_0_0, '0', zeromq_rep_sink_0_2_2_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0_0_0_0_0_0_0, '0', zeromq_rep_sink_0_2_2_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0_0_0_0_0_0_0_0, '0', zeromq_rep_sink_0_2_2_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0_0_0_0_0_0_0_1, '0', zeromq_rep_sink_0_2_2_0_0_0_1, '0']
- [blocks_multiply_const_vxx_0_0_0_0_0_0_0_0_0_0_2, '0', zeromq_rep_sink_0_2_2_0_0_0_2, '0']
- [blocks_multiply_const_vxx_0_0_0_0_0_0_1, '0', blocks_add_xx_0, '6']
- [blocks_multiply_const_vxx_0_0_0_0_0_0_1_0, '0', blocks_add_xx_0, '7']
- [blocks_multiply_const_vxx_0_0_0_0_0_0_1_0_0, '0', blocks_add_xx_0, '8']
- [blocks_multiply_const_vxx_0_0_0_0_0_0_1_0_0_0, '0', blocks_add_xx_0, '9']
- [blocks_multiply_const_vxx_0_0_0_0_0_0_1_0_0_1, '0', blocks_add_xx_0, '10']
- [blocks_multiply_const_vxx_0_0_0_0_0_0_1_0_0_2, '0', blocks_add_xx_0, '11']
- [blocks_multiply_const_vxx_0_0_0_0_0_1, '0', zeromq_rep_sink_0_2_1, '0']
- [blocks_multiply_const_vxx_0_0_0_0_1, '0', zeromq_rep_sink_0_2_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', zeromq_rep_sink_0, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', zeromq_rep_sink_0_2, '0']
- [blocks_multiply_const_vxx_0_1_1, '0', zeromq_rep_sink_0_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_0_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_0_0_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_0_0_0_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_0_0_0_0_0_1, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_0_0_0_0_0_2, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_1, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_0_0_0_1, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_1_1, '0']
- [zeromq_req_source_0, '0', blocks_throttle_0, '0']
- [zeromq_req_source_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [zeromq_req_source_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [zeromq_req_source_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0_0, '0']
- [zeromq_req_source_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_0, '0']
- [zeromq_req_source_0_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_0_1, '0']
- [zeromq_req_source_0_0_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_0_1_0, '0']
- [zeromq_req_source_0_0_0_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_0_1_0_0, '0']
- [zeromq_req_source_0_0_0_0_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_0_1_0_0_0, '0']
- [zeromq_req_source_0_0_0_0_0_0_0_0_1, '0', blocks_multiply_const_vxx_0_0_0_0_0_0_1_0_0_1, '0']
- [zeromq_req_source_0_0_0_0_0_0_0_0_2, '0', blocks_multiply_const_vxx_0_0_0_0_0_0_1_0_0_2, '0']
- [zeromq_req_source_1, '0', blocks_multiply_const_vxx_0, '0']
- [zeromq_req_source_1_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
